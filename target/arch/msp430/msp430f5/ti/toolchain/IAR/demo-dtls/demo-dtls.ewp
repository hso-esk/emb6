# IAR project demo-dtls.ewp, settings and files
configuration CC120x_CLI (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MAC_ADDR_WORD=0x00bb; LOGGER_LEVEL=1; LOGGER_DEMO_DTLS=1; DEMO_USE_DTLS=1; NET_USE_RPL=1; WITH_CONTIKI=1; IAR_COMPILER
  ICC430.CCDiagSuppress: Pa050, Pe161
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls\client; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\aes; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\ecc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\sha2; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration CC120x_SRV (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x00aa; LOGGER_LEVEL=3; LOGGER_DEMO_DTLS=1; DEMO_USE_DTLS=1; CONF_USE_SERVER=1; NET_USE_RPL=1; WITH_CONTIKI=1; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls\server; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\aes; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\ecc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\sha2; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
  ICC430.IccLang: 0
configuration CC112x_CLI (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x00bb; LOGGER_LEVEL=1; LOGGER_DEMO_DTLS=1; DEMO_USE_DTLS; NET_USE_RPL=1; WITH_CONTIKI=1; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls\client; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\aes; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\ecc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\sha2; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
  ICC430.IccLang: 0
configuration CC112x_SRV (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x00aa; LOGGER_LEVEL=1; LOGGER_DEMO_DTLS=1; DEMO_USE_DTLS=1; CONF_USE_SERVER=1; NET_USE_RPL=1; WITH_CONTIKI=1; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls; ..\..\..\..\..\..\..\..\..\emb6\demo\dtls\server; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\aes; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\ecc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\dtls\sha2; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
  ICC430.IccLang: 0
  group demo
    ../../../../../../../../demo/: demo_main.c
  group emb6/demo/dtls/client
    ../../../../../../../../demo/dtls/client/: demo_dtls_cli.c
  group emb6/demo/dtls/server
    ../../../../../../../../demo/dtls/server/: demo_dtls_srv.c
  group emb6/emb6
    ../../../../../../../../emb6/: emb6.c
  group emb6/emb6/src/dll/dllc
    ../../../../../../../../emb6/src/dll/dllc/: dllc_802154.c dllc_null.c linkaddr.c
  group emb6/emb6/src/dll/dllsec
    ../../../../../../../../emb6/src/dll/dllsec/: dllsec_null.c
  group emb6/emb6/src/dll/framer
    ../../../../../../../../emb6/src/dll/framer/: framer_802154.c
  group emb6/emb6/src/dll/mac
    ../../../../../../../../emb6/src/dll/mac/: mac_802154.c mac_802154_ule.c mac_null.c smartmac_framer.c
  group emb6/emb6/src/net/dtls
    ../../../../../../../../emb6/src/net/dtls/: ccm.c crypto.c debug.c dtls.c dtls_time.c hmac.c netq.c peer.c session.c
  group emb6/emb6/src/net/dtls/aes
    ../../../../../../../../emb6/src/net/dtls/aes/: rijndael.c
  group emb6/emb6/src/net/dtls/ecc
    ../../../../../../../../emb6/src/net/dtls/ecc/: ecc.c
  group emb6/emb6/src/net/dtls/sha2
    ../../../../../../../../emb6/src/net/dtls/sha2/: sha2.c
  group emb6/emb6/src/net/ipv6
    ../../../../../../../../emb6/src/net/ipv6/: nbr-table.c tcpip.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip6.c uiplib.c
  group emb6/emb6/src/net/ipv6/multicast
    ../../../../../../../../emb6/src/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group emb6/emb6/src/net/rpl
    ../../../../../../../../emb6/src/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-timers.c rpl.c
  group emb6/emb6/src/net/sicslowpan
    ../../../../../../../../emb6/src/net/sicslowpan/: framer-802154.c framer.c sicslowpan.c
  group emb6/emb6/src/phy
    ../../../../../../../../emb6/src/phy/: phy_802154.c phy_framer_802154.c phy_null.c
  group emb6/emb6/src/tport
    ../../../../../../../../emb6/src/tport/: tcp-socket.c udp-socket.c
  group emb6/target/arch/msp430/msp430x5/ti/device/msp430f5xxx/src
    ../../../device/msp430f5xxx/src/: infoflash.c int.c io.c key.c lcd.c lcd_dogm128_6_alphabet.c led.c low_level_init.c mcu.c rtc.c spi.c tmr.c uart.c
  group emb6/target/bsp
    ../../../../../../../bsp/: bsp.c
  group emb6/target/bsp/ti_trxeb_cc112x
    ../../../../../../../bsp/ti_trxeb_cc112x/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc120x
    ../../../../../../../bsp/ti_trxeb_cc120x/: board_conf.c
  group emb6/target/if/cc112x
    ../../../../../../../if/cc112x/: cc112x.c cc112x_spi.c
  group emb6/target/if/cc120x
    ../../../../../../../if/cc120x/: cc120x.c cc120x_spi.c
  group emb6/target/mcu/msp430f5438a
    ../../../../../../../mcu/msp430f5438a/: msp430x5xx.c
  group emb6/utils/src
    ../../../../../../../../utils/src/: ctimer.c etimer.c evproc.c lib_crc.c lib_tmr.c list.c memb.c mmem.c packetbuf.c queuebuf.c random.c ringbuffer.c stimer.c timer.c
