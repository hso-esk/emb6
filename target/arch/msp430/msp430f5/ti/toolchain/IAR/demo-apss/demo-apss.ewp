# IAR project demo-apss.ewp, settings and files
configuration CC1120_TX (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NETSTK_CFG_LPM_EN=1; STK_CFG_REFACTOR_EN=1; LPR_TX; IAR_COMPILER; RF_CCA_ON_TX= FALSE; TDD_SYNC_MODE=1
  ICC430.CCDiagSuppress: Pa050, Pe161
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\src; ..\..\..\..\..\..\..\..\..\src\emb6\target; ..\..\..\..\..\..\..\..\..\src\emb6\target\arch\msp430\ti\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\bsp\ti_trxeb; ..\..\..\..\..\..\..\..\..\src\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\if\cc1120; ..\..\..\..\..\..\..\..\..\src\emb6\emb6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\src\emb6\utils\inc
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration CC1120_RX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: NETSTK_CFG_LPM_EN=1; STK_CFG_REFACTOR_EN=1; LPR_RX; IAR_COMPILER; RF_CCA_ON_TX= FALSE; TDD_SYNC_MODE=1
configuration CC1120_RX_NORMAL (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: STK_CFG_REFACTOR_EN=1; SMARTMAC_RX; IAR_COMPILER; RF_CCA_ON_TX= FALSE
configuration CC1120_TX_NORMAL (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: STK_CFG_REFACTOR_EN=1; SMARTMAC_TX; IAR_COMPILER; RF_CCA_ON_TX= FALSE
configuration CC1200_RX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: LPR_RX; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc120x_ule; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc120x; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
configuration CC1200_TX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: LPR_TX; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
configuration CC112X_TX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: LPR_TX; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc112x_ule; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
configuration CC112X_RX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: LPR_RX; IAR_COMPILER
  ICC430.newCCIncludePaths: as above
  group demo
    ../../../../../../../../demo/: demo-netstk.c
  group emb6/emb6
    ../../../../../../../../emb6/: emb6.c
  group emb6/emb6/src/dll/framer
    ../../../../../../../../emb6/src/dll/framer/: framer_802154.c
  group emb6/emb6/src/dll/llc
    ../../../../../../../../emb6/src/dll/llc/: linkaddr.c llc_802154.c llc_null.c
  group emb6/emb6/src/dll/mac
    ../../../../../../../../emb6/src/dll/mac/: mac_802154.c mac_802154_ule.c mac_null.c smartmac_framer.c
  group emb6/emb6/src/phy
    ../../../../../../../../emb6/src/phy/: phy_null.c
  group emb6/target/arch/msp430/msp430x5/ti/device/msp430f5xxx/src
    ../../../device/msp430f5xxx/src/: infoflash.c int.c io.c key.c lcd.c lcd_dogm128_6_alphabet.c led.c low_level_init.c mcu.c rtc.c spi.c tmr.c uart.c
  group emb6/target/bsp
    ../../../../../../../bsp/: bsp.c
  group emb6/target/bsp/ti_trxeb_cc112x_ule
    ../../../../../../../bsp/ti_trxeb_cc112x_ule/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc120x_ule
    ../../../../../../../bsp/ti_trxeb_cc120x_ule/: board_conf.c
  group emb6/target/if/cc1120
    ../../../../../../if/cc1120/: cc1120.c cc1120_hal_io.c
  group emb6/target/if/cc112x
    ../../../../../../../if/cc112x/: cc112x.c cc112x_spi.c
  group emb6/target/if/cc120x
    ../../../../../../../if/cc120x/: cc120x.c cc120x_spi.c
  group emb6/target/mcu/msp430f5438
    ../../../../../../../mcu/msp430f5438a/: msp430x5xx.c
  group emb6/utils/src
    ../../../../../../../../utils/src/: ctimer.c etimer.c evproc.c lib_crc.c lib_tmr.c list.c memb.c mmem.c packetbuf.c queuebuf.c random.c ringbuffer.c stimer.c timer.c
