# IAR project demo-udp.ewp, settings and files
configuration CC1120_TX (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EMB6_INIT_ROOT=0; NET_USE_RPL=1; DEMO_USE_UDPALIVE=1; STK_CFG_REFACTOR_EN=1; SMARTMAC_TX; IAR_COMPILER; RF_CCA_ON_TX= FALSE; TDD_SYNC_MODE=1
  ICC430.CCDiagSuppress: Pa050, Pe161
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\src; ..\..\..\..\..\..\..\..\..\src\emb6\target; ..\..\..\..\..\..\..\..\..\src\emb6\target\arch\msp430\ti\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\bsp\ti_trxeb; ..\..\..\..\..\..\..\..\..\src\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\if\cc1120; ..\..\..\..\..\..\..\..\..\src\emb6\emb6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\src\emb6\demo\udp_alive; ..\..\..\..\..\..\..\..\..\src\emb6\utils\inc
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration CC1120_RX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: EMB6_INIT_ROOT=1; NET_USE_RPL=1; DEMO_USE_UDPALIVE=1; STK_CFG_REFACTOR_EN=1; SMARTMAC_RX; IAR_COMPILER; RF_CCA_ON_TX= FALSE; TDD_SYNC_MODE=1
configuration CC1120_TX_LPM (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: NETSTK_CFG_LPM_EN=1; STK_CFG_REFACTOR_EN=1; SMARTMAC_TX; IAR_COMPILER; RF_CCA_ON_TX= FALSE; TDD_SYNC_MODE=1
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\src; ..\..\..\..\..\..\..\..\..\src\emb6\target; ..\..\..\..\..\..\..\..\..\src\emb6\target\arch\msp430\ti\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\bsp\ti_trxeb; ..\..\..\..\..\..\..\..\..\src\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\if\cc1120; ..\..\..\..\..\..\..\..\..\src\emb6\emb6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\src\emb6\utils\inc
configuration CC1120_RX_LPM (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: NETSTK_CFG_LPM_EN=1; STK_CFG_REFACTOR_EN=1; SMARTMAC_RX; IAR_COMPILER; RF_CCA_ON_TX= FALSE; TDD_SYNC_MODE=1
  ICC430.newCCIncludePaths: as above
configuration UDP_SOCKET_CLIENT (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: EMB6_INIT_ROOT=0; NET_USE_RPL=1; DEMO_USE_UDP_SOCKET=1; STK_CFG_REFACTOR_EN=1; SMARTMAC_TX; IAR_COMPILER; RF_CCA_ON_TX= FALSE
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\src; ..\..\..\..\..\..\..\..\..\src\emb6\target; ..\..\..\..\..\..\..\..\..\src\emb6\target\arch\msp430\ti\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\bsp\ti_trxeb; ..\..\..\..\..\..\..\..\..\src\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\src\emb6\target\if\cc1120; ..\..\..\..\..\..\..\..\..\src\emb6\emb6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llsec; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\llc; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\src\emb6\emb6\inc\phy\lpr; ..\..\..\..\..\..\..\..\..\src\emb6\demo\udp_socket; ..\..\..\..\..\..\..\..\..\src\emb6\utils\inc
configuration UDP_SOCKET_SERVER (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: EMB6_INIT_ROOT=1; NET_USE_RPL=1; DEMO_USE_UDP_SOCKET=1; STK_CFG_REFACTOR_EN=1; SMARTMAC_RX; IAR_COMPILER; RF_CCA_ON_TX= FALSE
  ICC430.newCCIncludePaths: as above
  group demo
    ../../../../../../../demo/: demo_main.c
  group emb6/demo/udp_alive
    ../../../../../../../demo/udp_alive/: demo_udp_alive.c
  group emb6/demo/udp_socket
    ../../../../../../../demo/udp_socket/: demo_udp_socket.c
  group emb6/emb6
    ../../../../../../../emb6/: emb6.c
  group emb6/emb6/src/dll/framer
    ../../../../../../../emb6/src/dll/framer/: framer_802154.c
  group emb6/emb6/src/dll/llc
    ../../../../../../../emb6/src/dll/llc/: linkaddr.c llc_802154.c llc_null.c
  group emb6/emb6/src/dll/llsec
    ../../../../../../../emb6/src/dll/llsec/: llsec_null.c
  group emb6/emb6/src/dll/mac
    ../../../../../../../emb6/src/dll/mac/: mac_802154.c
  group emb6/emb6/src/net/ipv6
    ../../../../../../../emb6/src/net/ipv6/: nbr-table.c tcpip.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip6.c uiplib.c
  group emb6/emb6/src/net/ipv6/multicast
    ../../../../../../../emb6/src/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group emb6/emb6/src/net/rpl
    ../../../../../../../emb6/src/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-timers.c rpl.c
  group emb6/emb6/src/net/sicslowpan
    ../../../../../../../emb6/src/net/sicslowpan/: framer-802154.c framer.c sicslowpan.c
  group emb6/emb6/src/phy
    ../../../../../../../emb6/src/phy/: phy_null.c
  group emb6/emb6/src/phy/lpr
    ../../../../../../../emb6/src/phy/lpr/: lib_tmr.c lpr_apss.c lpr_null.c smartmac_framer.c xmac_framer.c
  group emb6/emb6/src/tport
    ../../../../../../../emb6/src/tport/: tcp-socket.c udp-socket.c
  group emb6/target
    ../../../../../../bsp/: bsp.c
  group emb6/target/arch/msp430/ti/msp430x5xx
    ../../../msp430x5xx/: infoflash.c int.c io.c key.c lcd.c lcd_dogm128_6_alphabet.c led.c low_level_init.c mcu.c rtc.c spi.c tmr.c uart.c
  group emb6/target/bsp/ti_trxeb
    ../../../../../../bsp/ti_trxeb/: board_conf.c bsp_lums.c
  group emb6/target/if/cc1120
    ../../../../../../if/cc1120/: cc1120.c cc1120_hal_io.c
  group emb6/target/if/cc1200
    ../../../../../../if/cc1200/: cc1200.c cc1200.h hal_cc1200_io.c hal_cc1200_io.h rf.c rf.h rf_cfg.h
  group emb6/target/if/cc1200/phy
    ../../../../../../if/cc1200/phy/: phy.c phy.h phy_pib.c phy_pib.h
  group emb6/target/mcu/msp430x5xx
    ../../../../../../mcu/msp430x5xx/: msp430x5xx.c
  group emb6/utils/src
    ../../../../../../../utils/src/: ctimer.c etimer.c evproc.c list.c memb.c mmem.c packetbuf.c queuebuf.c random.c ringbuffer.c stimer.c timer.c
